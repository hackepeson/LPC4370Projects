# IAR project PATest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4370_M4 NXP LPC4370_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: supportFiles\brd_link4370\inc; supportFiles\chip_43xx_18xx\inc; supportFiles\chip_43xx_18xx\config_43xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PATest.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lpc18xx_43xx_ldscript_spifi.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: adc.c adc.h gpio.c gpio.h main.c timer.c timer.h uart.c uart.h
  group supportFiles
    supportFiles/chip_43xx_18xx/startup/: iar_startup_lpc18xx43xx.s sysinit.c
  group supportFiles/board
    supportFiles/brd_link4370/src/: board.c board_sysinit.c retarget.h
  group supportFiles/chip
    supportFiles/chip_43xx_18xx/src/: chip_18xx_43xx.c clock_18xx_43xx.c fpu_init.c gpdma_18xx_43xx.c gpio_18xx_43xx.c hsadc_18xx_43xx.c sysinit_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c
